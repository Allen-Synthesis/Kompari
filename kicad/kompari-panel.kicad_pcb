File: kicad/kompari-panel.kicad_pcb (KiCad board)
At the start: 2 copper layers, 29.5 x 128.5 mm, 0 parts

Commit message: add black panel
Other:
- board text added: "a > b ?"
